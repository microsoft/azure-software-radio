options:
  parameters:
    author: Microsoft
    generate_options: qt_gui
    id: DIFI_PAIRED_EXAMPLE
    output_language: python
    title: DIFI Paired Example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: azure_software_radio_difi_sink_cpp_0
  id: azure_software_radio_difi_sink_cpp
  parameters:
    bit_depth: '8'
    context_pack_size: '72'
    context_packet_send_count: '1000'
    data_size: '255'
    ip_addr: 127.0.0.1
    mode: 'True'
    oui: '0'
    packet_class: '0'
    port: '50003'
    protocol: '1'
    reference_point: '101'
    reference_time_frac: '0'
    reference_time_full: '18000'
    sample_rate: '100000'
    stream_id: '0'
    type: complex
  states: {}
- name: azure_software_radio_difi_source_cpp_0
  id: azure_software_radio_difi_source_cpp
  parameters:
    bit_depth: '8'
    ip_addr: 127.0.0.1
    port: '50001'
    protocol: '1'
    socket_buffer_size: '2048'
    stream_num: '0'
    type: complex
  states: {}

connections:
- [azure_software_radio_difi_source_cpp_0, '0', azure_software_radio_difi_sink_cpp_0, '0']

metadata:
  file_format: 1
