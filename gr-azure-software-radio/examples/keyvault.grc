options:
  parameters:
    author: bquantump
    generate_options: qt_gui
    id: vaulttest
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: keyvault_0
  id: keyvault
  parameters:
    key: three
    keyvault_name: integkv
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32000*4
  states: {}
- name: scramble
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: sec
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: secretconnectionstring
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: seed
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: int(keyvault_0)
    type: complex
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_complex_to_real_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
