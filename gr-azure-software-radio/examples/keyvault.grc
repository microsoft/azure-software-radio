options:
  parameters:
    author: bquantump
    generate_options: qt_gui
    id: vaulttest
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: default_credentials_0
  id: azure_software_radio_default_credentials
  parameters:
    authority: login.microsoftonline.com
    azure_cli: 'True'
    azure_powershell: 'True'
    environment: 'True'
    interactive: 'False'
    managed_id: 'True'
    mode: 'False'
    shared_token_cache: 'False'
    visual_studio: 'True'
  states: {}
- name: key_vault_name
  id: variable
  parameters:
    value: '''change-me'''
  states: {}
- name: mysecretstring
  id: keyvault
  parameters:
    default_cred: default_credentials_0
    key: '''mysecretstring'''
    keyvault_name: key_vault_name
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32000*4
  states: {}
- name: scramble
  id: keyvault
  parameters:
    default_cred: default_credentials_0
    key: '''scramble'''
    keyvault_name: key_vault_name
    value: '0'
  states: {}
- name: seed
  id: keyvault
  parameters:
    default_cred: default_credentials_0
    key: '''seed'''
    keyvault_name: key_vault_name
    value: '0'
  states: {}
- name: azure_software_radio_blob_sink_0
  id: azure_software_radio_blob_sink
  parameters:
    authentication_method: connection_string
    blob_name: stuff2
    block_len: '500000'
    connection_str: mysecretstring
    container_name: demostore
    queue_size: '4'
    retry_total: '10'
    type: fc32
    url: ''
    vlen: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1,0)
  states: {}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    len: '7'
    mask: int(scramble)
    seed: int(seed)
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_char_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', azure_software_radio_blob_sink_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_throttle_0, '0', digital_scrambler_bb_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [digital_scrambler_bb_0, '0', blocks_char_to_float_0, '0']

metadata:
  file_format: 1
