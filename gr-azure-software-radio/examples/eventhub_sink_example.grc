options:
  parameters:
    author: Johanna Rivera
    copyright: Copyright (c) Microsoft Corporation
    description: Simple Event Hub Sink example that uses connection string authentication to send probe rate events.
    generate_options: qt_gui
    id: eventhub_sink_example
    output_language: python
    title: Event Hub Sink example
  states: {}

blocks:
- name: connection_str
  id: variable
  parameters:
    value: os.getenv('AZURE_EVENTHUB_CONNECTION_STRING')
  states: {}
- name: eventhub_name
  id: variable
  parameters:
    value: os.getenv('AZURE_EVENTHUB_NAME')
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: azure_software_radio_eventhub_sink_0
  id: azure_software_radio_eventhub_sink
  parameters:
    authentication_method: connection_string
    connection_str: connection_str
    eventhub_host_name: ''
    eventhub_name: eventhub_name
    partition_id: ''
    sas: ''
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_probe_rate_0, rate, azure_software_radio_eventhub_sink_0, in]
- [blocks_throttle_0, '0', blocks_probe_rate_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
