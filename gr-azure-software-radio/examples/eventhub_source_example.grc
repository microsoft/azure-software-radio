options:
  parameters:
    author: Johanna Rivera
    copyright: Copyright (c) Microsoft Corporation
    description: Simple Event Hub example that uses connection string authentication to receive events.
    generate_options: no_gui
    id: eventhub_example
    output_language: python
    title: EventHub Source example
  states: {}

blocks:
- name: connection_str
  id: variable
  parameters:
    value: os.getenv('AZURE_EVENTHUB_CONNECTION_STRING')
  states: {}
- name: consumer_grp
  id: variable
  parameters:
    value: os.getenv('AZURE_EVENTHUB_CONSUMER_GROUP')
  states: {}
- name: eventhub_name
  id: variable
  parameters:
    value: os.getenv('AZURE_EVENTHUB_NAME')
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: azure_software_radio_eventhub_source_0
  id: azure_software_radio_eventhub_source
  parameters:
    authentication_method: connection_string
    connection_str: connection_str
    consumer_grp: consumer_grp
    eventhub_host_name: ''
    eventhub_name: eventhub_name
    partition_id: ''
    sas: ''
    starting_position: '''-1'''
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}

connections:
- [azure_software_radio_eventhub_source_0, out, blocks_message_debug_0, print]

metadata:
  file_format: 1
