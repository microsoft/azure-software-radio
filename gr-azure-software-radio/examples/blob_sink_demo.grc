options:
  parameters:
    generate_options: qt_gui
    id: blob_source
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: keyvault_0
  id: keyvault
  parameters:
    keys: '["mysecretconnection", ("secretscramble", "scramble"), "seed"]'
    value: grconvault
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: azure_software_radio_blob_source_0
  id: azure_software_radio_blob_source
  parameters:
    authentication_method: connection_string
    blob_name: stuff2
    connection_str: mysecretconnection
    container_name: demostore
    url: ''
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_time_sink_x_1, '0']
- [azure_software_radio_blob_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
