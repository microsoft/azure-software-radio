options:
  parameters:
    generate_options: no_gui
    id: blob_sink_rate
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: block_len
  id: variable
  parameters:
    value: int(500000)*200
  states: {}
- name: connection_str
  id: env_variable
  parameters:
    env_var_name: '''AZURE_STORAGE_CONNECTION_STRING'''
    strict_checking: 'True'
    value: '''foo'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 50e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: azure_software_radio_blob_sink_0
  id: azure_software_radio_blob_sink
  parameters:
    blob_name: '''rate_test.npy'''
    block_len: block_len
    connection_str: connection_str
    container_name: '''cp-test'''
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: block_len*100
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_head_0, '0', azure_software_radio_blob_sink_0, '0']
- [blocks_head_0, '0', blocks_probe_rate_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_throttle_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
