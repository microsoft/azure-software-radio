options:
  parameters:
    author: Microsoft
    generate_options: qt_gui
    id: DIFI_STAND_ALONE_EXAMPLE
    output_language: python
    title: DIFI Standalone Example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '127'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: azure_software_radio_difi_sink_cpp_0
  id: azure_software_radio_difi_sink_cpp
  parameters:
    bit_depth: '8'
    context_pack_size: '72'
    context_packet_send_count: '1000'
    data_size: '128'
    ip_addr: 127.0.0.1
    mode: 'False'
    oui: '0'
    packet_class: '0'
    port: '50003'
    protocol: '2'
    reference_point: '101'
    reference_time_frac: '0'
    reference_time_full: '0'
    sample_rate: '100000'
    stream_id: '0'
    type: complex
  states: {}
- name: azure_software_radio_difi_source_cpp_0_0
  id: azure_software_radio_difi_source_cpp
  parameters:
    bit_depth: '8'
    ip_addr: 127.0.0.1
    port: '50003'
    protocol: '2'
    socket_buffer_size: '4096'
    stream_num: '0'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '4096'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '4096'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [azure_software_radio_difi_source_cpp_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle_0, '0', azure_software_radio_difi_sink_cpp_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
