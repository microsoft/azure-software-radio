options:
  parameters:
    author: Craig Pomeroy
    copyright: Copyright (c) Microsoft Corporation
    description: Azure Blob Source example that uses the DefaultAzureCredential for authentication
    generate_options: qt_gui
    id: blob_source_example
    output_language: python
    title: Simple Blob Source Example
  states: {}

blocks:
- name: blob_container_name
  id: variable
  parameters:
    value: '''blob-example'''
  states: {}
- name: blob_name
  id: variable
  parameters:
    value: '''test-signal.dat'''
  states: {}
- name: blob_url
  id: variable
  parameters:
    value: '''https://<changeme-blob-storage-account-name>.blob.core.windows.net'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: azure_software_radio_blob_source_0
  id: azure_software_radio_blob_source
  parameters:
    authentication_method: default
    blob_name: blob_name
    connection_str: ''
    container_name: blob_container_name
    queue_size: '4'
    retry_total: '0'
    type: fc32
    url: blob_url
    vlen: '1'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Blob Signal Display"'
    type: complex
  states: {}

connections:
- [azure_software_radio_blob_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
