options:
  parameters:
    generate_options: qt_gui
    id: fm_listen
    output_language: python
    title: fm_listen
  states: {}

blocks:
- name: freq_shift
  id: variable_qtgui_range
  parameters:
    label: Frequency Shift
    start: '-1e6'
    step: 0.1e6
    stop: 1e6
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '0.1'
    stop: '2'
    value: '0.2'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 500e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: azure_software_radio_blob_source_0
  id: azure_software_radio_blob_source
  parameters:
    authentication_method: url_with_sas
    blob_name: fm_wide_2MHz_repeated.i16
    connection_str: ''
    container_name: fm-radio
    queue_size: '4'
    retry_total: '10'
    type: s16
    url: https://softwareradiohelloworld.blob.core.windows.net
    vlen: '1'
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1'
    vector_input: 'False'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: freq_shift
    comment: |-
      Gets us down to 2 MHz and
      allows us to frequency shift
    decim: '1'
    samp_rate: samp_rate
    taps: ' firdes.low_pass(1,samp_rate,0.95e6, 0.1e6)'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: Gets us to 0.5 MHz
    cutoff_freq: 100e3
    decim: '4'
    gain: '1'
    samp_rate: 2e6
    type: fir_filter_ccf
    width: 50e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: 2e6
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: After Freq Shift
    type: complex
    ymax: '-20'
    ymin: '-100'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    bw: samp_rate
    fc: 100e6
    fftsize: '1024'
    name: Original 20 MHz Wide
    type: complex
    ymax: '-20'
    ymin: '-80'
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate/40
    fc: '0'
    fftsize: '1024'
    name: After Low Pass Filter
    type: complex
    ymax: '-40'
    ymin: '-160'
  states: {state: disabled}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [azure_software_radio_blob_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', low_pass_filter_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
