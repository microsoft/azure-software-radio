options:
  parameters:
    author: Marc
    category: Custom
    generate_options: qt_gui
    id: adsb_rx
    output_language: python
    title: ADS-B Receiver
  states: {}

blocks:
- name: fs
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: threshold
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,1,1,1
    label: Detection Threshold
    type: real
    value: '0.010'
  states: {}
- name: adsb_decoder_0
  id: adsb_decoder
  parameters:
    error_corr: '"None"'
    msg_filter: '"Extended Squitter Only"'
    print_level: '"Brief"'
  states: {}
- name: adsb_framer_1
  id: adsb_framer
  parameters:
    fs: fs
    threshold: threshold
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: threshold
    type: float
  states: {}
- name: azure_software_radio_blob_source_0
  id: azure_software_radio_blob_source
  parameters:
    authentication_method: connection_string
    blob_name: adsb_capture.iq
    connection_str: BlobEndpoint=https://helloworldiq.blob.core.windows.net/;QueueEndpoint=https://helloworldiq.queue.core.windows.net/;FileEndpoint=https://helloworldiq.file.core.windows.net/;TableEndpoint=https://helloworldiq.table.core.windows.net/;SharedAccessSignature=sv=2020-08-04&ss=b&srt=sco&sp=rtf&se=2023-06-01T00:04:58Z&st=2022-01-19T17:04:58Z&spr=https&sig=iLm%2BaYgz6OaEtqmSYwr5vTccl%2FA4BZISvM1G3bMHSlY%3D
    container_name: adsb
    queue_size: '4'
    retry_total: '10'
    type: fc32
    url: https://helloworldiq.blob.core.windows.net/?sv=2020-08-04&ss=b&srt=sco&sp=rtf&se=2022-01-20T01:04:58Z&st=2022-01-19T17:04:58Z&spr=https,http&sig=FYf%2B3cZB9yKQFYo%2BYAaTmy4d%2BgU%2BDByhrRYf6ocGgzs%3D
    vlen: '1'
  states: {}
- name: azure_software_radio_eventhub_sink_0
  id: azure_software_radio_eventhub_sink
  parameters:
    authentication_method: connection_string
    connection_str: Endpoint=sb://marceventhub.servicebus.windows.net/;SharedAccessKeyName=sendandlisten;SharedAccessKey=owZzZvyt1IAK5eIQ0mmySbMT3lWhwdO75V+7Oo7Skbc=
    eventhub_host_name: ''
    eventhub_name: eventhub1
    partition_id: ''
    sas: ''
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: fs
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import datetime
      import numpy as np

      import pmt
      from gnuradio import gr

      SYMBOL_RATE = 1e6  # symbols/second
      MAX_NUM_BITS = 112

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          def __init__(self, fs=1.0):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='ADS-B Demod (Marc)',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )

              # Calculate the samples/symbol
              # ADS-B is modulated at 1 Msym/s with Pulse Position Modulation, so the effective
              # required fs is 2 Msps
              self.fs = fs
              #assert self.fs % SYMBOL_RATE == 0, "ADS-B Demodulator is designed to operate on an integer number of samples per symbol, not %f sps" % (self.fs / SYMBOL_RATE)
              self.sps = int(fs // SYMBOL_RATE)

              # Calculate current UTC time at block startup. Then we'll use burst sample offset to derive burst time.
              self.start_timestamp = (datetime.datetime.utcnow() - datetime.datetime(1970, 1, 1)).total_seconds()

              # Array of data bits
              self.bits = []
              self.bit_idx = 0
              self.straddled_packet = 0

              self.set_tag_propagation_policy(gr.TPP_ONE_TO_ONE)
              self.message_port_register_out(pmt.to_pmt("demodulated"))


          def work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]

              # If there was a packet that straddled the previous block and this
              # block, finish decoding it
              if self.straddled_packet == 1:
                  self.straddled_packet = 0

              # Get tags from ADS-B Framer block
              #tags = self.get_tags_in_window(0, 0, len(in0), pmt.to_pmt("burst"))
              tags = self.get_tags_in_range(0, self.nitems_read(0), self.nitems_read(0) + len(in0), pmt.to_pmt("burst")) # get_tags_in_window broken in 3.9.2 and 3.9.3
              
              for tag in tags:
                  # Grab metadata for this tag
                  value = pmt.to_python(tag.value)
                  snr = value[1] # SNR in power dBs

                  # Calculate the SOB and EOB offsets
                  sob_offset = tag.offset + (8)*self.sps # Start of burst index (middle of the "bit 1 pulse")
                  eob_offset = tag.offset + (8+112-1)*self.sps + self.sps/2 # End of burst index (middle of the "bit 0 pulse")

                  # Find the SOB and EOB indices in this block of samples
                  sob_idx = sob_offset - self.nitems_written(0)
                  eob_idx = eob_offset - self.nitems_written(0)

                  if eob_idx < len(input_items[0]):
                      # The packet is fully within this block of samples, so demod
                      # the entire burst

                      # Grab the amplitudes where the "bit 1 pulse" should be
                      bit1_idxs = range(sob_idx, sob_idx + self.sps*MAX_NUM_BITS, self.sps)
                      bit1_amps = in0[bit1_idxs]

                      # Grab the amplitudes where the "bit 0 pulse" should be
                      bit0_idxs = range(sob_idx + self.sps // 2, sob_idx + self.sps // 2 + self.sps*MAX_NUM_BITS, self.sps)
                      bit0_amps = in0[bit0_idxs]

                      self.bits = np.zeros(MAX_NUM_BITS, dtype=np.uint8)
                      self.bits[bit1_amps > bit0_amps] = 1

                      # Get a log-likelihood type function for probability of a
                      # bit being a 0 or 1.  Confidence of 0 is equally likely 0 or 1.
                      # Positive confidence levels are more likely 1 and negative values
                      # are more likely 0.
                      self.bit_confidence = 10.0*np.log10(bit1_amps/bit0_amps)

                      # Send PDU message to decoder
                      meta = pmt.to_pmt({
                          "timestamp": self.start_timestamp + tag.offset/self.fs,
                          "snr": snr,
                      })
                      vector = pmt.to_pmt(self.bits)
                      pdu = pmt.cons(meta, vector)
                      self.message_port_pub(pmt.to_pmt("demodulated"), pdu)

                      if False:
                          # Tag the 0 and 1 bits markers for debug
                          for ii in range(0,len(bit1_idxs)):
                              self.add_item_tag(
                                  0,
                                  self.nitems_written(0)+bit1_idxs[ii],
                                  pmt.to_pmt("bits"),
                                  pmt.to_pmt((1, ii, float(self.bit_confidence[ii]))),
                                  pmt.to_pmt("demod")
                              )
                              self.add_item_tag(
                                  0,
                                  self.nitems_written(0)+bit0_idxs[ii],
                                  pmt.to_pmt("bits"),
                                  pmt.to_pmt((0, ii, float(self.bit_confidence[ii]))),
                                  pmt.to_pmt("demod")
                              )

                  else:
                      # The packet is only partially contained in this block of
                      # samples, decode as much as possible
                      self.straddled_packet = 1

              out0[:] = in0
              return len(output_items[0])
    fs: fs
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """designed to go after gr-adsb's Decoder, it strips away the bits and leaves metadata"""

          def __init__(self):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='Pass Only ADS-B Meta',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_out(pmt.intern('msg_out'))
              self.message_port_register_in(pmt.intern('msg_in'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
       
          def handle_msg(self, msg):
              meta = pmt.car(msg) # first part of the cons, which in our case is the meta (see decoder.py within gr-adsb)
              self.message_port_pub(pmt.intern('msg_out'), meta)
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0,1,2
    label1: ''
    label2: ''
    legend: 'False'
    marker1: '0'
    nconnections: '2'
    size: int(fs*150e-6)
    srate: int(fs)
    tr_delay: '1.25e-6'
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"burst"'
    type: float
    update_time: 1.0/100.0
    ymin: '0'
  states: {}

connections:
- [adsb_decoder_0, decoded, epy_block_2, msg_in]
- [adsb_framer_1, '0', epy_block_0, '0']
- [analog_const_source_x_0, '0', qtgui_time_sink_x_0, '1']
- [azure_software_radio_blob_source_0, '0', blocks_throttle_0, '0']
- [blocks_complex_to_mag_squared_0, '0', adsb_framer_1, '0']
- [blocks_throttle_0, '0', blocks_complex_to_mag_squared_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, demodulated, adsb_decoder_0, demodulated]
- [epy_block_2, msg_out, azure_software_radio_eventhub_sink_0, in]

metadata:
  file_format: 1
