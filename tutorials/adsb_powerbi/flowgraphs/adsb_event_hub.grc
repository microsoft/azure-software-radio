options:
  parameters:
    author: Marc
    category: Custom
    generate_options: qt_gui
    id: adsb_rx
    output_language: python
    title: ADS-B Receiver
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: 1090e6
  states: {}
- name: fs
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: gain
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: Gain (dB)
    type: real
    value: '100'
  states: {}
- name: threshold
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,1,1,1
    label: Detection Threshold
    type: real
    value: '0.010'
  states: {}
- name: adsb_decoder_0
  id: adsb_decoder
  parameters:
    error_corr: '"None"'
    msg_filter: '"Extended Squitter Only"'
    print_level: '"Brief"'
  states: {}
- name: adsb_demod_0
  id: adsb_demod
  parameters:
    fs: 2e6
  states: {}
- name: adsb_framer_1
  id: adsb_framer
  parameters:
    fs: fs
    threshold: threshold
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: threshold
    type: float
  states: {}
- name: azure_software_radio_blob_source_0
  id: azure_software_radio_blob_source
  parameters:
    authentication_method: url_with_sas
    blob_name: adsb_capture.iq
    connection_str: BlobEndpoint=https://softwareradiohelloworld.blob.core.windows.net/;QueueEndpoint=https://softwareradiohelloworld.queue.core.windows.net/;FileEndpoint=https://softwareradiohelloworld.file.core.windows.net/;TableEndpoint=https://softwareradiohelloworld.table.core.windows.net/;SharedAccessSignature=sv=2020-08-04&ss=b&srt=sco&sp=rltf&se=2023-02-02T04:11:08Z&st=2022-01-21T20:11:08Z&spr=https&sig=kgp2ovWg3As21SWyZYL%2Fuk0%2FsutYSJQIq5XbIpMbXW8%3D
    container_name: adsb
    queue_size: '4'
    retry_total: '10'
    type: fc32
    url: https://softwareradiohelloworld.blob.core.windows.net
    vlen: '1'
  states: {}
- name: azure_software_radio_eventhub_sink_0
  id: azure_software_radio_eventhub_sink
  parameters:
    authentication_method: connection_string
    connection_str: ''
    eventhub_host_name: ''
    eventhub_name: ''
    partition_id: ''
    sas: ''
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: fs
    type: complex
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """designed to go after gr-adsb's Decoder, it strips away the bits and leaves metadata"""

          def __init__(self):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='Pass Only ADS-B Meta',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_out(pmt.intern('msg_out'))
              self.message_port_register_in(pmt.intern('msg_in'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
       
          def handle_msg(self, msg):
              meta = pmt.car(msg) # first part of the cons, which in our case is the meta (see decoder.py within gr-adsb)
              self.message_port_pub(pmt.intern('msg_out'), meta)
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0,1,2
    label1: ''
    label2: ''
    legend: 'False'
    marker1: '0'
    nconnections: '2'
    size: int(fs*150e-6)
    srate: int(fs)
    tr_delay: '1.25e-6'
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"burst"'
    type: float
    update_time: 1.0/100.0
    ymin: '0'
  states: {}

connections:
- [adsb_decoder_0, decoded, epy_block_2, msg_in]
- [adsb_demod_0, '0', qtgui_time_sink_x_0, '0']
- [adsb_demod_0, demodulated, adsb_decoder_0, demodulated]
- [adsb_framer_1, '0', adsb_demod_0, '0']
- [analog_const_source_x_0, '0', qtgui_time_sink_x_0, '1']
- [azure_software_radio_blob_source_0, '0', blocks_throttle_0, '0']
- [blocks_complex_to_mag_squared_0, '0', adsb_framer_1, '0']
- [blocks_throttle_0, '0', blocks_complex_to_mag_squared_0, '0']
- [epy_block_2, msg_out, azure_software_radio_eventhub_sink_0, in]

metadata:
  file_format: 1
